Commit message: Create position controller

File: mujoco_elirobots/assets/ec63/ec63_description.urdf (robot description, URDF)
Before this commit: robot ec63, 13 links, 12 joints
Joints:
- joint joint1: limit lower=-6.2832 upper=6.2832 effort=90 velocity=3.3161 -> (none)
